v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 160 -130 0 0 {name=p1 lab=DVDD}
C {devices/ipin.sym} 160 -110 0 0 {name=p3 lab=VSS}
C {devices/ipin.sym} 160 -90 0 0 {name=p4 lab=SELA}
C {devices/ipin.sym} 160 -70 0 0 {name=p5 lab=SELB}
C {devices/ipin.sym} 160 -170 0 0 {name=p6 lab=VDD}
C {devices/ipin.sym} 160 -150 0 0 {name=p7 lab=DVSS}
C {Project/Package_IP/package_EF_R2RVC02/EF_R2RVC02/spice/xschem/EF_R2RVCX.sym} 670 -370 0 0 {name=x1}
C {devices/lab_pin.sym} 80 -600 0 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 80 -580 0 0 {name=p8 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 520 -400 0 0 {name=p13 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} 520 -420 0 0 {name=p14 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 520 -380 0 0 {name=p15 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 520 -360 0 0 {name=p16 sig_type=std_logic lab=VSS}
C {Project/Package_IP/package_EF_R2RVC02/EF_R2RVC02/spice/xschem/EF_AMUX21x.sym} 230 -540 0 0 {name=x2}
C {devices/lab_pin.sym} 80 -560 0 0 {name=p17 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 520 -340 0 0 {name=p18 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 80 -520 0 0 {name=p22 sig_type=std_logic lab=A1}
C {devices/lab_pin.sym} 80 -500 0 0 {name=p23 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 80 -480 0 0 {name=p11 sig_type=std_logic lab=SELA}
C {devices/lab_pin.sym} 80 -410 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 80 -390 0 0 {name=p10 sig_type=std_logic lab=DVDD}
C {Project/Package_IP/package_EF_R2RVC02/EF_R2RVC02/spice/xschem/EF_AMUX21x.sym} 230 -350 0 0 {name=x3}
C {devices/lab_pin.sym} 80 -370 0 0 {name=p12 sig_type=std_logic lab=vinm}
C {devices/lab_pin.sym} 80 -330 0 0 {name=p20 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 80 -310 0 0 {name=p24 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 80 -290 0 0 {name=p25 sig_type=std_logic lab=SELB}
C {devices/lab_pin.sym} 520 -320 0 0 {name=p26 sig_type=std_logic lab=vinm}
C {devices/ipin.sym} 300 -170 0 0 {name=p27 lab=A1}
C {devices/ipin.sym} 300 -140 0 0 {name=p28 lab=A2}
C {devices/ipin.sym} 390 -170 0 0 {name=p29 lab=B1}
C {devices/ipin.sym} 390 -140 0 0 {name=p30 lab=B2}
C {devices/ipin.sym} 160 -200 0 0 {name=p33 lab=VO}
C {devices/lab_pin.sym} 820 -420 0 1 {name=p34 sig_type=std_logic lab=VO}
C {devices/lab_pin.sym} 80 -540 0 0 {name=p19 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} 80 -350 0 0 {name=p21 sig_type=std_logic lab=DVSS}
