v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 160 -130 0 0 {name=p1 lab=vdd1p8}
C {devices/ipin.sym} 160 -110 0 0 {name=p3 lab=vss}
C {devices/ipin.sym} 160 -90 0 0 {name=p4 lab=sela}
C {devices/ipin.sym} 160 -70 0 0 {name=p5 lab=selb}
C {devices/ipin.sym} 160 -170 0 0 {name=p6 lab=vdd3p3}
C {devices/ipin.sym} 160 -150 0 0 {name=p7 lab=dvss}
C {Project/AR_SAR_ADC/comparator_top_02ch/schematic/EF_R2RVCXx.sym} 670 -370 0 0 {name=x1}
C {devices/lab_pin.sym} 80 -600 0 0 {name=p2 sig_type=std_logic lab=vdd3p3}
C {devices/lab_pin.sym} 80 -580 0 0 {name=p8 sig_type=std_logic lab=vdd1p8}
C {devices/lab_pin.sym} 520 -400 0 0 {name=p13 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} 520 -420 0 0 {name=p14 sig_type=std_logic lab=vdd1p8}
C {devices/lab_pin.sym} 520 -380 0 0 {name=p15 sig_type=std_logic lab=vdd3p3}
C {devices/lab_pin.sym} 520 -360 0 0 {name=p16 sig_type=std_logic lab=vss}
C {Project/AR_SAR_ADC/comparator_top_02ch/schematic/EF_AMUX21x.sym} 230 -540 0 0 {name=x2}
C {devices/lab_pin.sym} 80 -560 0 0 {name=p17 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 520 -340 0 0 {name=p18 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 80 -520 0 0 {name=p22 sig_type=std_logic lab=a1}
C {devices/lab_pin.sym} 80 -500 0 0 {name=p23 sig_type=std_logic lab=a2}
C {devices/lab_pin.sym} 80 -480 0 0 {name=p11 sig_type=std_logic lab=sela}
C {devices/lab_pin.sym} 80 -410 0 0 {name=p9 sig_type=std_logic lab=vdd3p3}
C {devices/lab_pin.sym} 80 -390 0 0 {name=p10 sig_type=std_logic lab=vdd1p8}
C {Project/AR_SAR_ADC/comparator_top_02ch/schematic/EF_AMUX21x.sym} 230 -350 0 0 {name=x3}
C {devices/lab_pin.sym} 80 -370 0 0 {name=p12 sig_type=std_logic lab=vinm}
C {devices/lab_pin.sym} 80 -330 0 0 {name=p20 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 80 -310 0 0 {name=p24 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 80 -290 0 0 {name=p25 sig_type=std_logic lab=selb}
C {devices/lab_pin.sym} 520 -320 0 0 {name=p26 sig_type=std_logic lab=vinm}
C {devices/ipin.sym} 300 -170 0 0 {name=p27 lab=a1}
C {devices/ipin.sym} 300 -140 0 0 {name=p28 lab=a2}
C {devices/ipin.sym} 390 -170 0 0 {name=p29 lab=b1}
C {devices/ipin.sym} 390 -140 0 0 {name=p30 lab=b2}
C {devices/ipin.sym} 160 -200 0 0 {name=p33 lab=vo}
C {devices/lab_pin.sym} 820 -420 0 1 {name=p34 sig_type=std_logic lab=vo}
C {devices/lab_pin.sym} 80 -540 0 0 {name=p19 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} 80 -350 0 0 {name=p21 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} 820 -400 0 1 {name=p31 sig_type=std_logic lab=avo}
C {devices/ipin.sym} 390 -100 0 0 {name=p32 lab=avo}
C {devices/ipin.sym} 460 -170 0 0 {name=p35 lab=vinp}
C {devices/ipin.sym} 460 -140 0 0 {name=p36 lab=vinm}
